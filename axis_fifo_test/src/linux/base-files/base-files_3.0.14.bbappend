SRC_URI += "file://fstab \
	"
FILESEXTRAPATHS_prepend := "${THISDIR}/base-files:"